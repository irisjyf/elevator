# Keil uVision project MasterCtrl.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: MainCtrl +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: EEPROM.C main.c RC522.C Time.c 74hc595.c
