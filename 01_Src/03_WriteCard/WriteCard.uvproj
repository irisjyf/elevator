# Keil uVision project WriteCard.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC11F16XE STC-STC11
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x3FFF) CLOCK(45000000) MODP2
  output: WriteCard +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Time.c main.c RC522.C EEPROM.C
